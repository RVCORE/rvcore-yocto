FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
BUSYBOX_SPLIT_SUID = "0"
