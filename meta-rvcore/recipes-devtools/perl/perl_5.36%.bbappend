FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

pkg_postinst_ontarget:${PN}-misc () {

}
