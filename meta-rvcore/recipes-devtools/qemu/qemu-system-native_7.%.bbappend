FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-forbid-sv57-in-qemuriscv64.patch"

