FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#COMPATIBLE_HOST:riscv64 = "riscv64-unknown-linux"
#COMPATIBLE_HOST:riscv32 = "riscv32-unknown-linux"
