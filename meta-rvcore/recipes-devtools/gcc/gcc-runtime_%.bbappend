#FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#RUNTIMETARGET += "libgfortran"
