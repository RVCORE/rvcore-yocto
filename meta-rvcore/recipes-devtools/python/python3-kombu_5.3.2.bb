SUMMARY = "fixtures defines a Python contract for reusable state / support logic, primarily for unit testing. "

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=daea7c168428449fbee05e644df929f4"


PYPI_SRC_URI = "https://files.pythonhosted.org/packages/bb/2e/95a2af69f9fc7f9c7b7a34f630843d843ee2de758934eb9694f6e3412094/kombu-5.3.2.tar.gz"
SRC_URI[sha256sum] = "0ba213f630a2cb2772728aef56ac6883dc3a2f13435e10048f6e97d48506dbbd"

inherit pypi setuptools3
