FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
DEPENDS:class-native = "ca-certificates-native"
