INSANE_SKIP = "configure-unsafe"
