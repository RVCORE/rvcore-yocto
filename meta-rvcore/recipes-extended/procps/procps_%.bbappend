FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
BBCLASSEXTEND = "native"
