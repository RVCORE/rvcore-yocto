FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#COMPATIBLE_MACHINE = "^(yinxing-fpga|qemuriscv64)$"
COMPATIBLE_HOST = "(x86_64|aarch64|mips64|powerpc64|riscv64).*-linux"
