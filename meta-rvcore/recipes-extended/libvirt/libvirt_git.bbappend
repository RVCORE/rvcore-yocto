FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

DEPENDS += "json-c"
