FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"


DEFAULT_TIMEZONE = "Asia/Shanghai"
