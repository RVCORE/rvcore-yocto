FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-linux-6.1.x-crash-caused-by-cpu_relax.patch"

